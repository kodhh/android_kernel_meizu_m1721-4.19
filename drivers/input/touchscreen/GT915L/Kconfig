## drivers/input/touchscreen/GT915L/Kconfig
```kconfig
config TOUCHSCREEN_GT915L
	tristate "GT915L touchscreens"
	depends on I2C
	default n
```
